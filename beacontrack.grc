<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>W.J. Ubbels PE4WJ</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Es'hailsat-2 Beacon tracker</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Es'hailsat-2 Beacon tracker</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>AF_gain</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>label</key><value>RX AF gain </value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>LNB_LO_freq</value></param>
<param><key>value</key><value>ref_freq*mult</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RX_frequency</value></param>
<param><key>value</key><value>tpx_center_freq-LNB_LO_freq</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>RX_gain</value></param>
<param><key>value</key><value>50</value></param>
<param><key>label</key><value>RX RF gain (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>80</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>beacontrack_bw</value></param>
<param><key>value</key><value>20000</value></param>
<param><key>label</key><value>beacon track bandwidth</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1000</value></param>
<param><key>step</key><value>100</value></param>
<param><key>stop</key><value>40000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>expected_beacon_freq</value></param>
<param><key>value</key><value>125000</value></param>
<param><key>label</key><value>Expected beacon frequency (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>level_tone</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>label</key><value>Audible beacon strength</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lnb_corr_ppm</value></param>
<param><key>value</key><value>24.8</value></param>
<param><key>label</key><value>LNB frequency correction (ppm)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-40</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>40</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>loop_bw</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>label</key><value>Beacon track loop BW</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>stop</key><value>0.1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lower_int</value></param>
<param><key>value</key><value>-84</value></param>
<param><key>label</key><value>wfall lower intensity</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-150</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>-80</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mult</value></param>
<param><key>value</key><value>390</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_amp</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>noise amplitude</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ref_freq</value></param>
<param><key>value</key><value>25*1e6*(1+lnb_corr_ppm*1e-6)</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>ref_freq_textbox</value></param>
<param><key>value</key><value>ref_freq/1e6</value></param>
<param><key>label</key><value>LNB reference freuency [MHz]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_audio_rate</value></param>
<param><key>value</key><value>44200</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>rx_freq_textbox_0</value></param>
<param><key>value</key><value>RX_frequency/1e6</value></param>
<param><key>label</key><value>USRP center frequency [MHz]</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>480000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tpx_center_freq</value></param>
<param><key>value</key><value>10489675000</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>track_beacon</value></param>
<param><key>value</key><value>0</value></param>
<param><key>false</key><value>0</value></param>
<param><key>label</key><value>Beacon track enable</value></param>
<param><key>true</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>tracked_bcn_freq_textbox</value></param>
<param><key>value</key><value>variable_function_probe_0*-1*(48000/decimation)</value></param>
<param><key>label</key><value>Tracked beacon freq (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>tracked_bcn_level_textbox</value></param>
<param><key>value</key><value>variable_function_probe_1</value></param>
<param><key>label</key><value>tracked_bcn_level_textbox</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>upper_int</value></param>
<param><key>value</key><value>-40</value></param>
<param><key>label</key><value>wfall upper intensity</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-40</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>40</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>var_freq</value></param>
<param><key>value</key><value>-151000</value></param>
<param><key>label</key><value>Frequency offset from center (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-200000</value></param>
<param><key>step</key><value>100</value></param>
<param><key>stop</key><value>200000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>var_freq_fine</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Fine tune (Hz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1250</value></param>
<param><key>step</key><value>10</value></param>
<param><key>stop</key><value>1250</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0</value></param>
<param><key>block_id</key><value>blocks_probe_signal_x_0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_1</value></param>
<param><key>block_id</key><value>analog_probe_avg_mag_sqrd_x_0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>variable_qtgui_entry_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>1e-2</value></param>
<param><key>comment</key><value>Fast attack, slow decay AGC</value></param>
<param><key>decay_rate</key><value>0.2</value></param>
<param><key>gain</key><value>10</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_0</value></param>
<param><key>attack_rate</key><value>1e-2</value></param>
<param><key>comment</key><value>Costas loop needs AGC (loop gain depends on input level)</value></param>
<param><key>decay_rate</key><value>0.2</value></param>
<param><key>gain</key><value>10</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_nbfm_tx</key>
<param><key>id</key><value>analog_nbfm_tx_0</value></param>
<param><key>audio_rate</key><value>48000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max_dev</key><value>5e3</value></param>
<param><key>fh</key><value>-1.0</value></param>
<param><key>quad_rate</key><value>samp_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>analog_probe_avg_mag_sqrd_x_0</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>threshold</key><value>0</value></param>
<param><key>type</key><value>c</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>level_tone*1</value></param>
<param><key>freq</key><value>500+variable_function_probe_1*200000000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate/decimation</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_2_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>comment</key><value>Downconversion oscillator</value></param>
<param><key>freq</key><value>var_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_2_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>comment</key><value>Downconversion oscillator</value></param>
<param><key>freq</key><value>var_freq_fine</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>device_name</key><value>hw:1,0</value></param>
<param><key>samp_rate</key><value>44100</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0</value></param>
<param><key>comment</key><value>Complex SSB filter (USB)</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>2700</value></param>
<param><key>low_cutoff_freq</key><value>300</value></param>
<param><key>samp_rate</key><value>rx_audio_rate</value></param>
<param><key>width</key><value>200</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
<param><key>comment</key><value>Make it a real signal</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0_0</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/wouter/Documents/Hobby/Eshailsat 2/beacontrack/gqrx_20190223_134030_739512600_500000_fc.raw</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>comment</key><value>Gate to enable / disable beacon tracking</value></param>
<param><key>const</key><value>track_beacon</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>comment</key><value>AF gain</value></param>
<param><key>const</key><value>AF_gain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>comment</key><value>Drift correction mixer</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1_0</value></param>
<param><key>comment</key><value>Downconverting mixer for tuning</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1_0_0</value></param>
<param><key>comment</key><value>Downconverting mixer for tuning</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_x_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>high</key><value>0.7</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>0</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>comment</key><value>Drift correction oscillator</value></param>
<param><key>samp_rate</key><value>480000</value></param>
<param><key>sensitivity</key><value>-1*(480000/decimation)</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>comment</key><value>Costas loop to lock to beacon</value></param>
<param><key>w</key><value>loop_bw</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>expected_beacon_freq</value></param>
<param><key>comment</key><value>Beacon receiver channelizer</value></param>
<param><key>decim</key><value>decimation</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), beacontrack_bw)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/decimation</value></param>
<param><key>width</key><value>5</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1</value></param>
<param><key>cutoff_freq</key><value>1000</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/decimation</value></param>
<param><key>width</key><value>4000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>Corrected input spectrum</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>8000</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>Costas loop output</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>upper_int</value></param>
<param><key>int_min</key><value>lower_int</value></param>
<param><key>label1</key><value>test</value></param>
<param><key>name</key><value>Corrected input spectrum</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>samp_rate</value></param>
<param><key>interp</key><value>rx_audio_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>480000/decimation</value></param>
<param><key>interp</key><value>480000</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_2</value></param>
<param><key>comment</key><value>Resample to 480 ks/sec</value></param>
<param><key>decim</key><value>500000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>samp_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_3</value></param>
<param><key>decim</key><value>rx_audio_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>48000</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_4</value></param>
<param><key>decim</key><value>samp_rate/decimation</value></param>
<param><key>interp</key><value>8000</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>145000000</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>70</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>RX_frequency</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>RX_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_0</value></param>
<param><key>avg_alpha</key><value>1</value></param>
<param><key>average</key><value>False</value></param>
<param><key>comment</key><value>Rudimentary lock indicator</value></param>
<param><key>decimal_places</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>factor</key><value>1</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>show_gauge</key><value>False</value></param>
<param><key>title</key><value>Lock state (0 = locked)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>units</key><value></value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_tx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_2_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_2_0_0</source_block_id><sink_block_id>blocks_conjugate_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0_0</source_block_id><sink_block_id>blocks_multiply_xx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>rational_resampler_xxx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1_0</source_block_id><sink_block_id>blocks_multiply_xx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1_0_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>wxgui_numbersink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>rational_resampler_xxx_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_agc2_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>low_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_probe_signal_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>analog_probe_avg_mag_sqrd_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qtgui_freq_sink_x_0</source_block_id><sink_block_id>analog_sig_source_x_2_0</sink_block_id><source_key>freq</source_key><sink_key>freq</sink_key></connection>
<connection><source_block_id>qtgui_waterfall_sink_x_0</source_block_id><sink_block_id>analog_sig_source_x_2_0</sink_block_id><source_key>freq</source_key><sink_key>freq</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>band_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>blocks_vco_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_2</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_2</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_3</source_block_id><sink_block_id>analog_nbfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_4</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
